options:
  parameters:
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Rx
  states: {}

blocks:
- name: SDR_ID
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: 8192*9
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/rx_file_sink_0.iq
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '40860'
    psize: 8192*9
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bandwidth
    bbdc: 'True'
    buffer_size: buffer_size
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: SDR_ID
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: 8192*9
    port: '40860'
    send_eof: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"RX"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: buffer_size
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: freq
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_udp_sink_1, '0']
- [iio_pluto_source_0, '0', network_udp_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', network_udp_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
