options:
  parameters:
    author: jasv22
    generate_options: qt_gui
    id: testTX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '3450000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '31'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: delta_pulse_delta_pulse_source_0
  id: delta_pulse_delta_pulse_source
  parameters:
    amplitude: '1'
    center: 'True'
    num_bins: '512'
    num_pulses: '-1'
    repeat: 'True'
    window: 'False'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [delta_pulse_delta_pulse_source_0, '0', uhd_usrp_sink_0, '0']
- [delta_pulse_delta_pulse_source_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
